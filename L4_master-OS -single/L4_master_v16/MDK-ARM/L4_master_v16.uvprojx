# Keil uVision project L4_master_v16.uvprojx, settings and files
target L4_master_v16 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L471RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: L4_master_v16 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L471xx
  c misc: --C99
  c include: ../Inc;                                                                                         ../Drivers/STM32L4xx_HAL_Driver/Inc;                                                                                         ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;                                                                                         ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;                                                                                         .\myuser;                                     ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;   ../Middlewares/Third_Party/FreeRTOS/Source/include;   ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;   ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Application/MDK-ARM
    ./: startup_stm32l471xx.s
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c main.c gpio.c stm32l4xx_it.c dma.c adc.c usart.c dac.c tim.c rtc.c freertos.c stm32l4xx_hal_timebase_TIM.c spi.c
    ./myuser/: my_extern_val.c my_gloabal_val.c my_usart.c my_usart_change.c my_led.c my_time.c my_ADC.c my_DAC.c my_exit.c my_wave_rec.c my_101.c my_101.h my_cc1101.c my_OS.c bsp_iap.c bsp_stm_flash.c my_extern_val.h my_gloabal_val.h my_ZSQ_Param.c
    ./: my_sysclc.c my_sysclc.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c queue.c tasks.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 5.0.0
