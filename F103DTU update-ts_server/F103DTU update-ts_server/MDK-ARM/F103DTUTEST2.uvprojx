# Keil uVision project F103DTUTEST2.uvprojx, settings and files
target F103DTUTEST2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F103DTUTEST2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;                      ../Drivers/STM32F1xx_HAL_Driver/Inc;                      ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                      ../Drivers/CMSIS/Include;                      ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                      .\myuser;                      ..\Drivers\CMSIS\Device\ST\STM32F1xx\Source\Templates\arm;        ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;        ../Middlewares/Third_Party/FreeRTOS/Source/include;        ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f1xx_hal_msp.c usart.c gpio.c spi.c rtc.c stm32f1xx_it.c tim.c freertos.c stm32f1xx_hal_timebase_TIM.c
    ./myuser/: bsp_led.c bsp_usart1.c my_def_value.c my_extrn_value.c my_usart.c bsp_spi_flash.c wdz_eeprom.c bsp_stm_flash.c my_time.c bsp_SysTick.c my_cc_TX_RX.c my_cc1101.c my_spi.c my_led.c my_exit.c wdz_m35.c my_gprs.c wdz_101.c wdz_MCU.c wdz_rtc_time.c my_OS.c my_OS.h bsp_iap.c my_globle_extern.h
    ../Inc/: FreeRTOSConfig.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi.c stm32f1xx_hal_rtc.c stm32f1xx_hal_tim.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c timers.c croutine.c event_groups.c tasks.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 5.0.0
